## boards/shields/ccmacropad/Kconfig.defconfig
```kconfig
if SHIELD_CCMACROPAD

config ZMK_KEYBOARD_NAME
    default "ccmacropad"

endif # SHIELD_CCMACROPAD
```
